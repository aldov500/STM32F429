# Keil uVision project starryNight.uvprojx, settings and files
target starryNight (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: starryNight +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_DEFAULT_TIMEOUT_CALLBACK,
  c include: .\..\;..\..\STM32\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\STM32\Libraries\CMSIS\Include;..\..\STM32\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\STM32\Utilities\Utilities\STM32F429I-Discovery;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c main.h stm32f4xx_it.h stm32f4xx_conf.h stm32f429_Paint.c
  group STM32F429I-Discovery
    ../../STM32/Utilities/Utilities/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_i2c_ee.c stm32f429i_discovery_ioe.c stm32f429i_discovery_l3gd20.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c
  group STM32F4xx_StdPeriph_Driver
    ../../STM32/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_fmc.c
software components: CMSIS:CORE 4.1.0, Device:Startup 2.1.0
